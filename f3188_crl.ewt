<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8S_StdPeriph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_adc1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_adc2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_awu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_beep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_itc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_rst.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim6.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_uart1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_uart2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_uart3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_uart4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_adc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_adc2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_awu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_uart2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_uart3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_uart4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8s_conf.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8s_it.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8s_it.h</name>
  </file>
</project>


